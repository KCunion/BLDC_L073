# Keil uVision project MM32L073_Demo.uvprojx, settings and files
target L073Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L072PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32L073_Demo +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe    --bin -o  ..\OBJ\MM32L073_Demo.bin ..\OBJ\MM32L073_Demo.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\MM32L0xx\Include;..\MM32L0xx\HAL_lib\inc;..\BSP\inc;..\SYSTEM\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../MM32L0xx/Source/KEIL_StartAsm/: startup_MM32L0xx.s
    ../MM32L0xx/Source/: system_MM32L0xx.c
  group HAL_Lib
    ../MM32L0xx/HAL_lib/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group BSP
    ../BSP/: hall.c key.c led.c pwm.c
  group SYSTEM
    ../SYSTEM/: sys.c systick.c uart.c
  group USER
    ../USER/: main.c
software components: CMSIS:CORE 5.0.1
