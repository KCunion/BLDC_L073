# IAR project MM32L073_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32L073PF MM MM32L073PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_IAR
  ICCARM.CCIncludePath2: ..\MM32L0xx\Include; ..\MM32L0xx\HAL_lib\inc; ..\SYSTEM\inc; ..\BSP\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MM32L073_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HAL/Lib
    ../MM32L0xx/HAL_lib/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HAL/Startup
    ../MM32L0xx/Source/IAR_StartAsm/: startup_MM32L0xx.s
    ../MM32L0xx/Source/: system_MM32L0xx.c
  group BSP
    ../BSP/: hall.c key.c led.c pwm.c
  group SYSTEM
    ../SYSTEM/: sys.c systick.c uart.c
  group USER
    ../USER/: main.c
